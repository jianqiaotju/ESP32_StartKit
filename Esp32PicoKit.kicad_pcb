# Repository jianqiaotju/ESP32_StartKit

## KiCad design Esp32PicoKit.kicad_pcb

Parts:
AE1: Antenna; Rainsun1003
C1, C3, C5: 10uf; C_0805_2012Metric
C2, C4, C6, C13, C14: 0.1uf; C_0805_2012Metric
C7, C8, C11, C12: 1uf; C_0805_2012Metric
C9: 4.7uf; C_0805_2012Metric
C10: 2.2uf; C_0805_2012Metric
D1: 1N4148; D_SOD-323
D2, D3: D_0603_1608Metric
DS1: OLED-128O064D
J1, J2, J3: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J4: USB4105-GF-A; USB-C_4105; PARTREV A3
Q1, Q2: S8050_1; SOT-23
R1, R2, R4, R9: 10K; R_0805_2012Metric
R3, R5: 5.1K; R_0805_2012Metric
R6, R7, R8, R11: 4.7k; R_0805_2012Metric
R10: 910k; R_0805_2012Metric
R12, R13, R14: 1K; R_0805_2012Metric
SW2, SW3: SW_SPST_CK_RS282G05A3
TP1, TP2: PinHeader_1x02_P2.54mm_Vertical
U1: AMS1117-3.3; SOT-223
U2: CP2102N-Axx-xQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U3: ESP32-PICO-D4; QFN-48-1EP_7x7mm_P0.5mm_EP5.3x5.3mm
U4: SHT20; XDCR_SHT20; PARTREV 4

Connections:
+3V3: C3.1, C6.1, C11.1, C12.1, C14.1, D1.1 (K), DS1.6 (VBAT), DS1.9 (VDD), DS1.11 (BS1), J3.9, R6.2, R7.2, R8.1, R9.1, R12.1, R13.1, U1.2 (VO), U3.1 (VDDA), U3.3 (VDDA3P3), U3.4 (VDDA3P3), U3.19 (VDD3P3_RTC), U3.37 (VDD3P3_CPU), U3.43 (VDDA), U3.46 (VDDA), U4.5 (VDD)
/D+: J4.A6 (DP1), J4.B6 (DP2), U2.4 (D+)
/D-: J4.A7 (DN1), J4.B7 (DN2), U2.5 (D-)
/DTR: Q2.2 (E), R1.1, U2.28 (~DTR)
/EN: Q1.3 (C), R9.2, R14.2, U3.9 (EN)
/ESP_SCL: DS1.18 (D0), R6.1, TP2.1, U4.6 (SCL)
/ESP_SDA: DS1.19 (D1), DS1.20 (D2), R7.1, TP1.1, U4.1 (SDA)
/GPIO2: J2.8, U3.22 (IO2)
/GPIO4: J2.7, U3.24 (IO4)
/GPIO5: J2.6, U3.34 (IO5)
/GPIO9: J2.5, U3.28 (SD2/IO9)
/GPIO10: J2.4, U3.29 (SD3/IO10)
/GPIO12: J2.3, U3.18 (IO12)
/GPIO13: J2.2, SW2.2, U3.20 (IO13)
/GPIO14: J2.1, U3.17 (IO14)
/GPIO15: J3.7, U3.21 (IO15)
/GPIO16: U3.25 (IO16)
/GPIO17: U3.27 (IO17)
/GPIO18: J3.6, U3.35 (IO18)
/GPIO19: J3.5, U3.38 (IO19)
/GPIO21: J3.4, TP1.2, U3.42 (IO21)
/GPIO22: J3.3, TP2.2, U3.39 (IO22)
/GPIO23: J3.2, U3.36 (IO23)
/GPIO25: J3.1, U3.14 (IO25)
/GPIO26: J1.10, U3.15 (IO26)
/GPIO27: D2.1 (K), J1.9, U3.16 (IO27)
/GPIO32: J1.8, U3.12 (IO32)
/GPIO33: J1.7, U3.13 (IO33)
/GPIO34: J1.6, U3.10 (IO34)
/GPIO35: J1.5, U3.11 (IO35)
/GPIO37: J1.2, U3.6 (SENSOR_CAPP)
/GPIO38: J1.3, U3.7 (SENSOR_CAPN)
/IO0: J2.9, Q2.3 (C), U3.23 (IO0)
/RTS: Q1.2 (E), R2.1, U2.24 (~RTS)
/RXD: U2.25 (RXD), U3.41 (U0TXD/IO1)
/SD_CLK: U3.31 (CLK)
/SD_CMD: U3.30 (CMD)
/SD_DATA0: U3.32 (SD0)
/SD_DATA1: U3.33 (SD1)
/SENSOR_VN: J1.4, U3.8 (SENSOR_VN)
/SENSOR_VP: J1.1, U3.5 (SENSOR_VP)
/TXD: U2.26 (TXD), U3.40 (U0RXD/IO3)
/VBUS: C1.1, C2.1, C4.1, J3.10, J4.A4_B9 (VBUS), J4.B4_A9 (VBUS), U1.3 (VI), U2.7 (VREGIN), U2.8 (VBUS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, D3.1 (K), DS1.1 (GND), DS1.8 (VSS), DS1.10 (BS0), DS1.12 (BS2), DS1.13 (~CS), DS1.16 (R/~W), DS1.17 (E/~RD), DS1.21 (D3), DS1.22 (D4), DS1.23 (D5), DS1.24 (D6), DS1.25 (D7), DS1.29 (VLSS), DS1.30 (GND), J2.10, J3.8, J4.A1_B12 (GND), J4.B1_A12 (GND), J4.S1 (SHELL_GND), J4.S2 (SHELL_GND), J4.S3 (SHELL_GND), J4.S4 (SHELL_GND), R3.1, R5.1, R10.2, R11.2, SW2.1, SW3.1, U1.1 (GND), U2.3 (GND), U2.29 (GND), U3.49 (GND), U4.2 (VSS)
unnamed: AE1.1 (A), U3.2 (LNA_IN)
unnamed: C5.1, D1.2 (A), DS1.14 (~RES), R8.2
unnamed: C7.1, DS1.3 (C2P)
unnamed: C7.2, DS1.2 (C2N)
unnamed: C8.1, DS1.5 (C1N)
unnamed: C8.2, DS1.4 (C1P)
unnamed: C9.1, DS1.27 (VCOMH)
unnamed: C10.1, DS1.28 (VCC)
unnamed: C13.2, R4.1, U2.6 (VDD)
unnamed: D2.2 (A), R12.2
unnamed: D3.2 (A), R13.2
unnamed: DS1.15 (D/~C), R11.1
unnamed: DS1.26 (IREF), R10.1
unnamed: J4.A5 (CC1), R3.2
unnamed: J4.B5 (CC2), R5.2
unnamed: Q1.1 (B), R1.2
unnamed: Q2.1 (B), R2.2
unnamed: R4.2, U2.9 (~RST)
unnamed: R14.1, SW3.2
unnamed: U4.3 (NC), U4.4 (NC)

Notes on the sheet:
Auto Program DTR RTS -> EN IO0 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 0
CORE
OLED显示，地址60
OLED 30Pins IIC
Sensor
USB-PROG
3.3V Power
Board Pins
温湿度传感器，地址81

Board: 2 copper layers, 88.9 x 58.4 mm, 48 parts (0 on the bottom side), 58 nets.

Other parts of the board:
 : R305Hole
